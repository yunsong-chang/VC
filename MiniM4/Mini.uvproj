# Keil uVision project Mini.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Mini
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./Source/ARM/: startup_ARMCM4.s
